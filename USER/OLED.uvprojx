# Keil uVision project OLED.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L031G6Ux STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: OLED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L053xx
  c include: ..\CORE;..\HARDWARE\OLED;..\STM32L0xx_HAL_Driver\Inc;..\STM32L0xx_HAL_Driver\Src;..\SYSTEM;..\USER;..\HARDWARE\OLED\uGUI_Driver;..\HARDWARE\OLED\uGUI_Library;..\HARDWARE\OLED\Windows
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group USER
    ./: main.c stm32l0xx_it.c stream_frame.c
    ../HARDWARE/OLED/: oled_menu.h oled_menu.c
    ../HARDWARE/OLED/Windows/: wnd_settime.c wnd_mainmenu.c wnd_popup.c
  group HANDWARE
    ../HARDWARE/OLED/: oled.c my_hal_spi.c my_hal_uart.c charlib.c my_hal_tim.c keypad.h GT21L16S2Y_STM32L031G6U6.lib GT21L16S2Y.h
    ../HARDWARE/OLED/uGUI_Driver/: ugui_SSD1309.c
    ../HARDWARE/OLED/uGUI_Library/: ugui.c
    ./: keypad.c
  group FWLib
    ../STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_rcc.c stm32l0xx_hal_spi.c stm32l0xx_hal_dma.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_tim.c
  group CORE
    ../CORE/: system_stm32l0xx.c startup_stm32l031xx.s
